# Keil uVision project tool_button.uvprojx, settings and files
target Cortex M4F (ARM-ADS)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: tool_button_m4f (library)
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\improt;..\include;..\source;..\reference\mcu_framework;..\reference\tool_timer_scheduler
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group include
    ../include/: tool_button.h
  group import
    ../improt/: version.h
  group source
    ../source/: tool_button.c
  group reference_mcu_framework
    ../reference/mcu_framework/: fw_io_pin.h fw_adc.h fw_adc_channel.h fw_base.h fw_i2cm.h fw_io.h fw_ioint.h fw_spim.h fw_timer.h fw_usart.h
  group reference_timer_scheduler
    ../reference/tool_timer_scheduler/: tool_timer_scheduler.h
    ../reference/tool_timer_scheduler/source/: tool_timer_scheduler.c
